# Keil uVision project M0_Templant_FreeRTOS.uvprojx, settings and files
target M0_Templant_FreeRTOS (6240000::V6.24::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: M0_Templant_FreeRTOS +hex
  BeforeMake: cmd.exe /C call "$Psyscfg.bat" "$P" main.syscfg
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ../,../Component,D:\tool\CCS\mspm0_sdk_2_10_00_04\source\third_party\CMSIS\Core\Include,D:\tool\CCS\mspm0_sdk_2_10_00_04\source,.\FreeRTOS\include,.\FreeRTOS\portable\GCC\ARM_CM0,.\FreeRTOS\portable\MemMang
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: D:\tool\CCS\mspm0_sdk_2_10_00_04\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group Source
    ../: main.c main.syscfg FreeRTOSConfig.h ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g350x_uvision.s
  group FreeRTOS/src
    ./FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ./FreeRTOS/portable/GCC/ARM_CM0/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group Component/led
    ../Component/led/: led.c led.h key.c key.h
  group Component/UART
    ../Component/UART/: uart0.c uart0.h
  group Component/oled
    ../Component/oled/: oled.c oled.h oledfont.h bmp.h
  group Component/mpu6050
    ../Component/mpu6050/: clock.c clock.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h mpu6050.c mpu6050.h mspm0_i2c.c mspm0_i2c.h dmpKey.h dmpmap.h
  group Component/tb6612
    ../Component/tb6612/: tb6612.c tb6612.h
  group Component/encoder
    ../Component/encoder/: encoder.c encoder.h
  group Component/pid
    ../Component/pid/: pid.c pid.h
  group Component/task
    ../Component/task/: app_tasks.c app_tasks.h
